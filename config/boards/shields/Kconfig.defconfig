## config/boards/shields/Kconfig.defconfig
```kconfig
if SHIELD_SETTINGS_RESET

config ZMK_KEYBOARD_NAME
	default "SETTINGS RESET"

endif
```
